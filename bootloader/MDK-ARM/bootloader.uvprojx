# Keil uVision project bootloader.uvprojx, settings and files
target n32l40x (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: N32L403KB Nationstech
  pack: Nationstech.N32L40x_DFP.0.1.0
  cpu: IRAM(0x20000000,0x6000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: debug +hex
  AfterMake: fromelf --bin --output=.\bootloader.bin .\Objects\debug.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: n32l40x, USE_STDPERIPH_DRIVER
  c include: ..\..\app\CMSIS\core;..\..\app\CMSIS\device;..\..\app\std_periph_lib\inc;..\user;..\user\sfud\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x6000
  group STARTUP
    ../CMSIS/device/startup/: startup_n32l40x.s
  group CMSIS
    ../CMSIS/device/: system_n32l40x.c
  group USER
    ../user/: main.c n32l40x_it.c dcd_user.c dcd_port.c af_utils.c af_port.c iap.c iap_addr_def.h addr_print.h
    ../user/sfud/src/: sfud.c sfud_sfdp.c
    ../user/sfud/port/: sfud_port.c
  group FWLB
    ../std_periph_driver/src/: misc.c n32l40x_flash.c n32l40x_gpio.c n32l40x_usart.c n32l40x_spi.c n32l40x_rcc.c
